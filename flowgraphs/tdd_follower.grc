options:
  parameters:
    author: tr-01
    generate_options: qt_gui
    id: tdd_follower
    output_language: python
    title: tdd_follower
  states: {}

blocks:
- name: band_width
  id: variable
  parameters:
    value: samp_rate//2
  states: {}
- name: dec
  id: variable_cc_decoder_def
  parameters:
    dim1: '1'
    framebits: framebits
    k: k
    mode: fec.CC_STREAMING
    ndim: '1'
    padding: 'False'
    polys: polys
    rate: rate
    state_end: '-1'
    state_start: '0'
  states: {}
- name: enc
  id: variable_cc_encoder_def
  parameters:
    dim1: '1'
    framebits: framebits
    k: k
    mode: fec.CC_STREAMING
    ndim: '1'
    padding: 'False'
    polys: polys
    rate: rate
    state_start: '0'
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: '64'
  states: {}
- name: frame_len
  id: variable
  parameters:
    value: '1'
  states: {}
- name: framebits
  id: variable
  parameters:
    value: fft_len
  states: {}
- name: guard_time_ms
  id: variable
  parameters:
    value: '100'
  states: {}
- name: half_period_ms
  id: variable
  parameters:
    value: '500'
  states: {}
- name: header_equalizer
  id: variable
  parameters:
    value: digital.ofdm_equalizer_simpledfe(fft_len, header_mod.base(), occupied_carriers, pilot_carriers, pilot_symbols)
  states: {}
- name: header_formatter
  id: variable
  parameters:
    value: digital.packet_header_ofdm(occupied_carriers, n_syms=1, len_tag_key=packet_length_tag_key, frame_len_tag_key=length_tag_key, bits_per_header_sym=header_mod.bits_per_symbol(), bits_per_payload_sym=payload_mod.bits_per_symbol(), scramble_header=False)
  states: {}
- name: header_mod
  id: variable
  parameters:
    value: digital.constellation_bpsk()
  states: {}
- name: k
  id: variable
  parameters:
    value: '7'
  states: {}
- name: length_tag_key
  id: variable
  parameters:
    value: '"frame_len"'
  states: {}
- name: occupied_carriers
  id: variable
  parameters:
    value: (list(range(-26, -21)) + list(range(-20, -7)) + list(range(-6, 0)) + list(range(1, 7)) + list(range(8, 21))+ list(range(22, 27)),)
  states: {}
- name: occupied_carriers_1024
  id: variable
  parameters:
    value: (list(range(-460, -300)) + list(range(-299, -150)) +list(range(-149, 0)) +  list(range(1, 150)) +list(range(151, 300)) + list(range(301, 460)),)
  states: {}
- name: occupied_carriers_128
  id: variable
  parameters:
    value: (list(range(-106, -49)) + list(range(-48, -35)) + list(range(-34, -21)) + list(range(-20, -7)) + list(range(-6, 0)) + list(range(1, 7))+list(range(8,21))+list(range(22,35))+list(range(36,49))+list(range(50,107)),)
  states: {}
- name: occupied_carriers_256
  id: variable
  parameters:
    value: (list(range(-106, -49)) + list(range(-48, -35)) + list(range(-34, -21)) + list(range(-20, -7)) + list(range(-6, 0)) + list(range(1, 7))+list(range(8,21))+list(range(22,35))+list(range(36,49))+list(range(50,107)),)
  states: {}
- name: occupied_carriers_64
  id: variable
  parameters:
    value: (list(range(-26, -21)) + list(range(-20, -7)) + list(range(-6, 0)) + list(range(1, 7)) + list(range(8, 12)),)
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: 640*3
  states: {}
- name: packet_length_tag_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: payload_equalizer
  id: variable
  parameters:
    value: digital.ofdm_equalizer_simpledfe(fft_len, payload_mod.base(), occupied_carriers, pilot_carriers, pilot_symbols, 1)
  states: {}
- name: payload_mod
  id: variable
  parameters:
    value: digital.qam.qam_constellation(constellation_points=64)
  states: {}
- name: pilot_carriers
  id: variable
  parameters:
    value: ((-21, -7, 7, 21,),)
  states: {}
- name: pilot_carriers_1024
  id: variable
  parameters:
    value: ((-300, -150, 150, 300,),)
  states: {}
- name: pilot_carriers_128
  id: variable
  parameters:
    value: ((),)
  states: {}
- name: pilot_symbols
  id: variable
  parameters:
    value: ((1, 1, 1, -1,),)
  states: {}
- name: pilot_symbols_128
  id: variable
  parameters:
    value: ((),)
  states: {}
- name: polys
  id: variable
  parameters:
    value: '[79, 109]'
  states: {}
- name: puncpat
  id: variable
  parameters:
    value: '''11'''
  states: {}
- name: rate
  id: variable
  parameters:
    value: '2'
  states: {}
- name: rolloff
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20480000//2
  states: {}
- name: sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: sync_word1
  id: variable
  parameters:
    value: '[0., 0., 0., 0., 0., 0., 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 0., 0., 0., 0., 0.]'
  states: {}
- name: sync_word1_1024
  id: variable
  parameters:
    value: '[0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0, 0., 0., 0., 0., 0., 0., 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0.,1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0.,1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0.,1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0.,1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0.,1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0.,1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0.,1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0.,1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0.,1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0.,1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0.,1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0.,1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0.,1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0.,1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0.,1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0.,1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 0., 0., 0., 0., 0., 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,]'
  states: {}
- name: sync_word1_128
  id: variable
  parameters:
    value: '[0., 0., 0., 0., 0., 0., 0., 0., 0., 0., 0., 0.,0., 0., 0., 0., 0., 0.,0., 0., 0., 0., 0., 0.,0., 0., 0., 0., 0., 0., 0., 0., 0., 0., 0., 0., 0., 0., 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 0., 0., 0., 0., 0., 0., 0., 0., 0., 0., 0., 0., 0., 0., 0., 0., 0.,0., 0., 0., 0., 0., 0.,0., 0., 0., 0., 0., 0.,0., 0., 0., 0., 0., 0.,0., 0.]'
  states: {}
- name: sync_word1_256
  id: variable
  parameters:
    value: '[0.,0.,0.,0.,0.,0.,0.,0.,0.,0.,0.,0.,0.,0.,0.,0.,0.,0.,0.,0.,0.,0.,0.,0.,0.,0.,0.,0.,0.,0.,0.,0.,0.,0.,0.,0.,0.,0.,0.,1.41421356,0.,-1.41421356,0.,1.41421356,0.,-1.41421356,0.,-1.41421356,0.,-1.41421356,0.,1.41421356,0.,-1.41421356,0.,1.41421356,0.,-1.41421356,0.,-1.41421356,0.,-1.41421356,0.,-1.41421356,0.,1.41421356,0.,-1.41421356,0.,1.41421356,0.,-1.41421356,0.,-1.41421356,0.,-1.41421356,0.,1.41421356,0.,-1.41421356,0.,1.41421356,0.,-1.41421356,0.,-1.41421356,0.,-1.41421356,0.,-1.41421356,0.,-1.41421356,0.,1.41421356,0.,-1.41421356,0.,-1.41421356,0.,-1.41421356,0.,-1.41421356,0.,1.41421356,0.,-1.41421356,0.,1.41421356,0.,-1.41421356,0.,-1.41421356,0.,-1.41421356,0.,1.41421356,0.,-1.41421356,0.,1.41421356,0.,-1.41421356,0.,-1.41421356,0.,-1.41421356,0.,-1.41421356,0.,1.41421356,0.,-1.41421356,0.,1.41421356,0.,1.41421356,0.,1.41421356,0.,-1.41421356,0.,1.41421356,0.,1.41421356,0.,1.41421356,0.,-1.41421356,0.,1.41421356,0.,1.41421356,0.,1.41421356,0.,1.41421356,0.,-1.41421356,0.,1.41421356,0.,1.41421356,0.,1.41421356,0.,-1.41421356,0.,1.41421356,0.,-1.41421356,0.,1.41421356,0.,1.41421356,0.,1.41421356,0.,-1.41421356,0.,1.41421356,0.,1.41421356,0.,1.41421356,0.,-1.41421356,0.,1.41421356,0.,1.41421356,0.,1.41421356,0.,1.41421356,0.,-1.41421356,0.,1.41421356,0.,1.41421356,0.,1.41421356,0.,-1.41421356,0.,1.41421356,0.,1.41421356,0.,1.41421356,0.,-1.41421356,0.,1.41421356,0.,1.41421356,0.,1.41421356,0.,0.,0.,0.,0.,0.,0.,0.,0.,0.,0.,0.,0.,0.,0.,0.,0.,0.,0.,0.,0.,0.,0.,0.,0.,0.,0.,0.,0.,0.,0.,0.,0.,0.,0.,0.,0.,0.]'
  states: {}
- name: sync_word1_64
  id: variable
  parameters:
    value: '[0., 0., 0., 0., 0., 0., 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 0., 0., 0., 0., 0.]'
  states: {}
- name: sync_word2
  id: variable
  parameters:
    value: '[0j, 0j, 0j, 0j, 0j, 0j, (-1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1 +0j), (1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), 0j, (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), 0j, 0j, 0j, 0j, 0j]'
  states: {}
- name: sync_word2_1024
  id: variable
  parameters:
    value: '[0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j,0j, 0j, 0j, 0j, 0j, 0j,0j, 0j, 0j, 0j, 0j, 0j,0j, 0j, 0j, 0j, 0j, 0j,0j, 0j, 0j, 0j, 0j, 0j,0j, 0j, 0j, 0j, 0j, 0j,0j,0j, (-1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1 +0j), (1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1 +0j), (1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j),(-1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1 +0j), (1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j),(-1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1 +0j), (1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j),(-1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1 +0j), (1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j),(-1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1 +0j), (1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j),(-1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1 +0j), (1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j),(-1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1 +0j), (1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j),(-1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1 +0j), (1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j),(-1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1 +0j), (1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j),(-1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1 +0j), (1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j),(-1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1 +0j), (1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j),(-1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1 +0j), (1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j),(-1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1 +0j), (1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j),(-1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1 +0j), (1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j),(-1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1 +0j), (1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j),(-1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1 +0j), (1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j),(-1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1 +0j), (1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), 0j, (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j),(1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j),(1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j),(1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j),(1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j),(1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j),(1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j),(1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j),(1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j),(1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j),(1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j),(1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j),(1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j),(1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j),(1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j),(1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j),(1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j),(1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j,0j,0j,0j]'
  states: {}
- name: sync_word2_128
  id: variable
  parameters:
    value: '[0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, (-1+0j), (-1+0j), (1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (-1+0j), 0j, (-1+0j), (1+0j), (1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), 0j, 0j, 0j, 0j, 0j, 0j, 0j]'
  states: {}
- name: sync_word2_256
  id: variable
  parameters:
    value: '[0j,0j,0j,0j,0j,0j,0j,0j,(-1+0j),(-1+0j),(1+0j),(-1+0j),(1+0j),(-1+0j),(-1+0j),(1+0j),(-1+0j),(1+0j),(-1+0j),(-1+0j),(-1+0j),(-1+0j),(1+0j),(-1+0j),(-1+0j),(-1+0j),(1+0j),(1+0j),(1+0j),(-1+0j),(-1+0j),(1+0j),(-1+0j),(-1+0j),(-1+0j),(-1+0j),(1+0j),(-1+0j),(-1+0j),(-1+0j),(1+0j),(1+0j),(-1+0j),(-1+0j),(1+0j),(-1+0j),(-1+0j),(1+0j),(-1+0j),(1+0j),(1+0j),(1+0j),(-1+0j),(1+0j),(1+0j),(1+0j),(-1+0j),(-1+0j),(-1+0j),(1+0j),(1+0j),(1+0j),(-1+0j),(-1+0j),(-1+0j),(-1+0j),(1+0j),(-1+0j),(1+0j),(-1+0j),(-1+0j),(1+0j),(-1+0j),(1+0j),(-1+0j),(-1+0j),(-1+0j),(-1+0j),(1+0j),(-1+0j),(-1+0j),(-1+0j),(1+0j),(1+0j),(1+0j),(-1+0j),(-1+0j),(1+0j),(-1+0j),(-1+0j),(-1+0j),(-1+0j),(1+0j),(-1+0j),(-1+0j),(-1+0j),(1+0j),(1+0j),(-1+0j),(-1+0j),(1+0j),(-1+0j),(-1+0j),(1+0j),(-1+0j),(1+0j),(1+0j),(1+0j),(-1+0j),(1+0j),(1+0j),(1+0j),(-1+0j),(-1+0j),(-1+0j),(1+0j),(1+0j),(1+0j),(-1+0j),(-1+0j),(-1+0j),(-1+0j),(-1+0j),(1+0j),(1+0j),(1+0j),(-1+0j),(-1+0j),0j,(-1+0j),(1+0j),(1+0j),(1+0j),(1+0j),(1+0j),(-1+0j),(-1+0j),(-1+0j),(1+0j),(1+0j),(1+0j),(1+0j),(1+0j),(-1+0j),(-1+0j),(-1+0j),(1+0j),(1+0j),(1+0j),(1+0j),(1+0j),(-1+0j),(-1+0j),(-1+0j),(-1+0j),(-1+0j),(1+0j),(-1+0j),(-1+0j),(-1+0j),(-1+0j),(-1+0j),(-1+0j),(1+0j),(-1+0j),(-1+0j),(-1+0j),(-1+0j),(1+0j),(1+0j),(-1+0j),(-1+0j),(-1+0j),(1+0j),(-1+0j),(-1+0j),(-1+0j),(-1+0j),(1+0j),(-1+0j),(-1+0j),(-1+0j),(1+0j),(1+0j),(1+0j),(-1+0j),(-1+0j),(-1+0j),(-1+0j),(-1+0j),(1+0j),(1+0j),(1+0j),(-1+0j),(1+0j),(1+0j),(1+0j),(1+0j),(1+0j),(-1+0j),(-1+0j),(-1+0j),(1+0j),(1+0j),(1+0j),(1+0j),(1+0j),(-1+0j),(-1+0j),(-1+0j),(-1+0j),(-1+0j),(1+0j),(-1+0j),(-1+0j),(-1+0j),(-1+0j),(-1+0j),(-1+0j),(1+0j),(-1+0j),(-1+0j),(-1+0j),(-1+0j),(1+0j),(1+0j),(-1+0j),(-1+0j),(-1+0j),(1+0j),(-1+0j),(-1+0j),(-1+0j),(-1+0j),(1+0j),(-1+0j),(-1+0j),(-1+0j),(1+0j),(1+0j),(1+0j),(-1+0j),(-1+0j),(-1+0j),(-1+0j),(-1+0j),(1+0j),(1+0j),(1+0j),0j,0j,0j,0j,0j,0j,0j]'
  states: {}
- name: sync_word2_64
  id: variable
  parameters:
    value: '[0j, 0j, 0j, 0j, 0j, 0j, (-1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1 +0j), (1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), 0j, (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), 0j, 0j, 0j, 0j, 0j]'
  states: {}
- name: variable_repetition_decoder_def_0
  id: variable_repetition_decoder_def
  parameters:
    framebits: '2048'
    ndim: '0'
    prob: '0.5'
    rep: '3'
  states: {}
- name: variable_repetition_encoder_def_0
  id: variable_repetition_encoder_def
  parameters:
    framebits: '2048'
    ndim: '0'
    rep: '3'
  states: {}
- name: InFile
  id: parameter
  parameters:
    label: File Name
    type: str
    value: '"./input.txt"'
  states: {}
- name: analog_frequency_modulator_fc_0_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: '-0.1/fft_len'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '255'
    min: '0'
    num_samps: packet_len
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_copy_0
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: fft_len+fft_len//4
    type: complex
  states: {}
- name: blocks_file_sink_0_1_0_0
  id: blocks_file_sink
  parameters:
    file: /home/tr-03/Bumhee/prev_tdd/received_binary_stream.bin
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_0_3_2_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: header_seriallizer.txt
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_3_2_1_1_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: data_serializer.txt
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_3_2_1_1_0_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: data_out_rx.txt
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/tr-03/Mohsen/Demo_Berlin_Jun24/Transmitter/Two_Users/Demo_GUI/1.ts
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '50'
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.05'
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_null_sink_2
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: byte
  states: {}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '8'
    l: payload_mod.bits_per_symbol()
    len_tag_key: length_tag_key
  states: {}
- name: blocks_repack_bits_bb_0_0_0
  id: blocks_repack_bits_bb
  parameters:
    align_output: 'True'
    endianness: gr.GR_LSB_FIRST
    k: payload_mod.bits_per_symbol()
    l: '8'
    len_tag_key: packet_length_tag_key
  states: {}
- name: blocks_stream_to_tagged_stream_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: length_tag_key
    packet_len: packet_len
    type: byte
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    name: TX end
    type: complex
  states: {state: disabled}
- name: blocks_tag_debug_2
  id: blocks_tag_debug
  parameters:
    filter: '"tx_sob"'
    name: Tag Mux
    type: complex
  states: {state: disabled}
- name: blocks_tag_debug_2_0
  id: blocks_tag_debug
  parameters:
    filter: '"tx_eob"'
    name: Tag Mux
    type: complex
  states: {state: disabled}
- name: blocks_tag_debug_2_0_0
  id: blocks_tag_debug
  parameters:
    filter: '"tx_eob"'
    name: Tag ofdm
    type: complex
    vlen: '64'
  states: {state: disabled}
- name: blocks_tag_debug_2_0_0_0
  id: blocks_tag_debug
  parameters:
    filter: '"tx_eob"'
    name: fft
    type: complex
    vlen: '64'
  states: {state: disabled}
- name: blocks_tag_debug_2_0_0_1
  id: blocks_tag_debug
  parameters:
    filter: '"tx_eob"'
    name: cp
    type: complex
  states: {state: disabled}
- name: blocks_tag_debug_2_0_1
  id: blocks_tag_debug
  parameters:
    filter: '"tx_eob"'
    name: Tag Hdr
    type: byte
  states: {state: disabled}
- name: blocks_tag_debug_2_0_2
  id: blocks_tag_debug
  parameters:
    filter: '"tx_eob"'
    name: Tag Bits
    type: byte
  states: {state: disabled}
- name: blocks_tag_debug_2_0_2_0
  id: blocks_tag_debug
  parameters:
    filter: '"tx_eob"'
    name: Tagged
    type: byte
  states: {state: disabled}
- name: blocks_tag_debug_2_1
  id: blocks_tag_debug
  parameters:
    filter: '"tx_sob"'
    name: Tag ofdm
    type: complex
    vlen: '64'
  states: {state: disabled}
- name: blocks_tag_debug_2_1_0
  id: blocks_tag_debug
  parameters:
    filter: '"tx_sob"'
    name: fft
    type: complex
    vlen: '64'
  states: {state: disabled}
- name: blocks_tag_debug_2_1_1
  id: blocks_tag_debug
  parameters:
    filter: '"tx_sob"'
    name: cp
    type: complex
  states: {state: disabled}
- name: blocks_tag_debug_2_2
  id: blocks_tag_debug
  parameters:
    filter: '"tx_sob"'
    name: Tag Hdr
    type: byte
  states: {state: disabled}
- name: blocks_tag_debug_2_3
  id: blocks_tag_debug
  parameters:
    filter: '"tx_sob"'
    name: Tag Bits
    type: byte
  states: {state: disabled}
- name: blocks_tag_debug_2_3_0
  id: blocks_tag_debug
  parameters:
    filter: '"tx_sob"'
    name: Tagged
    type: byte
  states: {state: disabled}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    single_key: '"frame_len"'
    type: complex
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: length_tag_key
    ninputs: '2'
    type: complex
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: '64'
    type: complex
  states: {state: disabled}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: header_mod.points()
  states: {}
- name: digital_chunks_to_symbols_xx_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: payload_mod.points()
  states: {}
- name: digital_constellation_decoder_cb_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: header_mod.base()
  states: {}
- name: digital_constellation_decoder_cb_1_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: payload_mod.base()
  states: {}
- name: digital_header_payload_demux_0_0
  id: digital_header_payload_demux
  parameters:
    guard_interval: fft_len//4
    header_len: '3'
    header_padding: '0'
    items_per_symbol: fft_len
    length_tag_key: length_tag_key
    output_symbols: 'True'
    samp_rate: samp_rate
    special_tags: ()
    timing_tag_key: '"rx_time"'
    type: complex
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[-1, 1]'
  states: {state: disabled}
- name: digital_ofdm_carrier_allocator_cvc_0
  id: digital_ofdm_carrier_allocator_cvc
  parameters:
    fft_len: fft_len
    len_tag_key: length_tag_key
    occupied_carriers: occupied_carriers
    output_is_shifted: 'True'
    pilot_carriers: pilot_carriers
    pilot_symbols: pilot_symbols
    sync_words: (sync_word1, sync_word2)
  states: {}
- name: digital_ofdm_chanest_vcvc_0_0
  id: digital_ofdm_chanest_vcvc
  parameters:
    force_one_symbol: 'False'
    max_carr_offset: '3'
    n_data_symbols: '1'
    sync_symbol1: sync_word1
    sync_symbol2: sync_word2
  states: {}
- name: digital_ofdm_cyclic_prefixer_0
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: fft_len//4
    input_size: fft_len
    rolloff: rolloff
    tagname: length_tag_key
  states: {state: disabled}
- name: digital_ofdm_frame_equalizer_vcvc_0_0
  id: digital_ofdm_frame_equalizer_vcvc
  parameters:
    cp_len: fft_len//4
    equalizer: header_equalizer.base()
    fft_len: fft_len
    fixed_frame_len: '1'
    len_tag_key: length_tag_key
    propagate_channel_state: 'True'
  states: {}
- name: digital_ofdm_frame_equalizer_vcvc_1_0
  id: digital_ofdm_frame_equalizer_vcvc
  parameters:
    cp_len: fft_len//4
    equalizer: payload_equalizer.base()
    fft_len: fft_len
    len_tag_key: length_tag_key
    propagate_channel_state: 'True'
  states: {}
- name: digital_ofdm_serializer_vcc_header_0
  id: digital_ofdm_serializer_vcc
  parameters:
    carr_offset_key: ''
    fft_len: fft_len
    len_tag_key: length_tag_key
    occupied_carriers: occupied_carriers
    packet_len_tag_key: ''
  states: {}
- name: digital_ofdm_serializer_vcc_payload_0
  id: digital_ofdm_serializer_vcc
  parameters:
    carr_offset_key: ''
    fft_len: fft_len
    len_tag_key: length_tag_key
    occupied_carriers: occupied_carriers
    packet_len_tag_key: packet_length_tag_key
    symbols_skipped: '1'
  states: {}
- name: digital_ofdm_sync_sc_cfb_0_0
  id: digital_ofdm_sync_sc_cfb
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    threshold: '0.9'
  states: {}
- name: digital_packet_headergenerator_bb_0
  id: digital_packet_headergenerator_bb
  parameters:
    header_formatter: header_formatter.base()
    len_tag_key: length_tag_key
  states: {}
- name: digital_packet_headerparser_b_0_0
  id: digital_packet_headerparser_b
  parameters:
    header_formatter: header_formatter.base()
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block    

          def __init__(self, sampl_rate=1e6, tx_time = 1):  # only default arguments here
              #latency in microsec
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Burst Tagger',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.sampl_rate = sampl_rate
              self.tx_time = tx_time
              self.counter = 0
              self.enable = 1 #1-tx/0-rx
              self.tot_sampl = tx_time*sampl_rate
              self.eob_tag_key = "tx_eob"
              self.sob_tag_key = "tx_sob"
              self.time_tag_key = "tx_time"

              self.msg_port_name = "usrp_toggle"
              self.message_port_register_in(pmt.intern(self.msg_port_name))
              self.set_msg_handler(pmt.intern(self.msg_port_name),self.handler)

          def handler(self, msg):
              #pass
              print(self.counter,", ",self.enable)
              if self.enable == 2:
                  self.enable = 0
              elif self.enable == 0:
                  self.enable == 1

          def work(self, input_items, output_items):
              
              if self.enable != 1:
                  return 0
              
              noutput_items = len(output_items[0])
              self.counter += noutput_items
              offset = self.nitems_written(0)

              if self.counter >= self.tot_sampl:
                  self.add_item_tag(0, int(offset + noutput_items -1), #(self.tot_sampl-self.counter) - 1,
                      pmt.string_to_symbol(self.eob_tag_key),
                      pmt.PMT_T)
                  self.counter = 0
                  self.enable = 0
              elif not self.counter and self.enable == 1:
                                  # Time tag
                  # time_spec = uhd.time_spec_t(self.next_time)
                  # self.add_item_tag(0, offset,
                  #     pmt.string_to_symbol(self.time_tag_key),
                  #     pmt.make_tuple(
                  #     pmt.from_uint64(time_spec.get_full_secs()),
                  #     pmt.from_double(time_spec.get_frac_secs())))
                  
                  self.add_tag(0, offset,
                      pmt.string_to_symbol(self.sob_tag_key),
                      pmt.PMT_T)

              output_items[0][:] = input_items[0][:]
              #[:(self.tot_sampl-self.counter)]

              return noutput_items
    sampl_rate: '1000000.0'
    tx_time: '.4'
  states: {state: disabled}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      #Atx 1	    	Brx 0
      #Atx 2/1		Brx 0
      #strobe-STOP
      #Arx 2/3		Brx 0
      #strobe-SWITCH
      #Arx 0        	Brx 1
      #Arx 0      	Brx 2/1
      #strobe-STOP
      #Arx 0  	    Brx 2/3
      #strobe-SWITCH
      #Arx 1  	    Brx 0


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, sampl_rate=1e6, tx_time = 1):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Random Source',   # will show up in GRC
                  in_sig=None, #[np.complex64],
                  out_sig=[np.byte]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.sampl_rate = sampl_rate
              self.tx_time = tx_time
              self.counter = 0
              self.enable = 0 #1-tx/0-rx
              self.tot_sampl = tx_time*sampl_rate
              self.eob_tag_key = "tx_eob"
              self.sob_tag_key = "tx_sob"
              self.time_tag_key = "tx_time"

              self.msg_port_name = "file_pause"
              self.message_port_register_in(pmt.intern(self.msg_port_name))
              self.set_msg_handler(pmt.intern(self.msg_port_name),self.handler)

          def handler(self, msg):
              #pass
              print("tx-rndsrc msg",self.counter,", ",self.enable,", ", msg)
              message = pmt.to_python(msg)
              if msg == pmt.intern("SWITCH"):
                  if self.enable == 0:
                      self.enable = 2 #from rx -> tx
                  elif self.enable == 1:
                      self.enable = 0 #from eob sent mode -> rx

              elif msg == pmt.intern("STOP"):
                  if self.enable == 0:
                      self.enable = 0
                  elif self.enable == 2:
                      self.enable = 3 #need to send eob asap
                  #for 1 ie eob already sent keep it as is, flip it when switch msg arrives
                  #for 0 ie rx mode keep as is & flip when switch msg comes
                  
              else:
                  print("MSG Dont know")
                  
                  
                  # if self.enable == 2:
                  #     self.enable = 0
                  # elif self.enable == 0:
                  #     self.enable = 1
                  

          def work(self, input_items, output_items):
              # print("tx-rndsrc-entr",self.counter,", ",self.enable)
              if self.enable < 2:
                  # print("tx-rndsrc-entr AA",self.counter,", ",self.enable)
                  return 0
              
              noutput_items = len(output_items[0])
              # noutput_items = len(out)
              offset = self.nitems_written(0)
              self.counter += noutput_items
              
              if (self.counter) >= self.tot_sampl or self.enable == 3:
                  # print("tx-rndsrc-eob",self.counter,", ",self.enable)
                  # output_items[0][:] =  np.ones(noutput_items, dtype=np.byte) #(self.tot_sampl-self.counter), dtype=np.byte)
                  
                  self.add_item_tag(0, int(offset + noutput_items -1), #(self.tot_sampl-self.counter) - 1,
                      pmt.string_to_symbol(self.eob_tag_key),
                      pmt.PMT_T)
                  output_items[0][:] =  np.random.randint(-128,127,1, dtype=np.byte)
                  self.enable = 2
                  self.counter = 0
              else:
                  if self.counter == noutput_items:
                  # print("tx-rndsrc-sob",self.counter,", ",self.enable)
                      self.add_item_tag(0, offset,
                          pmt.string_to_symbol(self.sob_tag_key),
                          pmt.PMT_T)
                  if noutput_items >= self.tot_sampl:
                      noutput_items = self.tot_sampl
                  output_items[0][:] =  np.random.randint(-128,127,noutput_items, dtype=np.byte)
              noutput_items = 0
              return noutput_items #len(output_items[0])
    sampl_rate: '4000000.0'
    tx_time: '.6'
  states: {state: disabled}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import time
      from threading import Thread


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, switching_interval=.05, guard_time=.01):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(  #basic_block.__init__(
                  self,
                  name='Strobe SW/ST',   # will show up in GRC
                  in_sig=[np.byte],
                  out_sig=[np.byte]#None #[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.switching_interval = switching_interval
              self.guard_time = guard_time
              self.enable = 0
              self.msg_port_src = "sw_st_trigger"
              self.message_port_register_out(pmt.intern(self.msg_port_src))
              self.msg_port_usrp_sink = "usrp_trigger"
              self.message_port_register_out(pmt.intern(self.msg_port_usrp_sink))
              self.state = 0
              self.t = Thread(target=self.runner, daemon=True)

          # def start(self):
          #     # t = Thread(target=self.run,args=(self,))
          #     self.t.start()

          # def stop(self):
          #     self.t.join()
          
          # def run(self,input_items, output_items):
          #     if input_items[0][0]:
          #         self.enable = 1

          #     while self.enable:
          #         time.sleep((self.switching_interval-self.guard_time))
          #         PMT_msg = pmt.intern("STOP")
          #         self.message_port_pub(pmt.intern(self.msg_port_name), PMT_msg)
          #         time.sleep((self.guard_time))
          #         PMT_msg = pmt.intern("SWITCH")
          #         self.message_port_pub(pmt.intern(self.msg_port_name), PMT_msg)
          def runner(self):
              print("In thread")
              while True:
                  time.sleep((self.switching_interval-self.guard_time))
                  PMT_msg = pmt.intern("STOP")
                  self.message_port_pub(pmt.intern(self.msg_port_src), PMT_msg)
                  time.sleep((self.guard_time))

                  stream_val = pmt.make_dict()
                  if self.state:
                      # PMT_msg = pmt.intern("")    #start recv as prev was tx                
                      stream_val = pmt.dict_add(stream_val,pmt.to_pmt("stream_mode"),pmt.to_pmt("start_cont"))
                      stream_val = pmt.dict_add(stream_val,pmt.to_pmt("stream_now"),pmt.PMT_T)
                      # PMT_T
                  else:
                      # PMT_msg = pmt.intern("")    #stop recv as prev was rx
                      stream_val = pmt.dict_add(stream_val,pmt.to_pmt("stream_mode"),pmt.to_pmt("stop_cont"))
                      stream_val = pmt.dict_add(stream_val,pmt.to_pmt("stream_now"),pmt.PMT_T)
                  self.state = (not self.state)   #state change
                  
                  stream_cmd = pmt.make_dict()
                  stream_cmd = pmt.dict_add(stream_cmd,pmt.to_pmt("stream_cmd"),stream_val)
                  self.message_port_pub(pmt.intern(self.msg_port_usrp_sink), stream_cmd)

                  PMT_msg = pmt.intern("SWITCH")
                  self.message_port_pub(pmt.intern(self.msg_port_src), PMT_msg)

          def work(self, input_items, output_items):
              # print(input_items[0])
              if input_items[0][0] and not self.enable:
                  self.enable = 1
              elif self.enable == 1:
                  return len(output_items[0])
              print("Start thread")
              
              if self.enable:
                  self.t.start()
              # while self.enable:
              #     time.sleep((self.switching_interval-self.guard_time))
              #     PMT_msg = pmt.intern("STOP")
              #     self.message_port_pub(pmt.intern(self.msg_port_name), PMT_msg)
              #     time.sleep((self.guard_time))
              #     PMT_msg = pmt.intern("SWITCH")
              #     self.message_port_pub(pmt.intern(self.msg_port_name), PMT_msg)

              # output_items[0][:] = input_items[0] * self.example_param
              # out = output_items[0]
              # return len(out)
              return  len(output_items[0])
    guard_time: '.03'
    switching_interval: '.1'
  states: {state: disabled}
- name: fec_extended_decoder_0
  id: fec_extended_decoder
  parameters:
    decoder_list: dec
    puncpat: puncpat
    threadtype: none
  states: {state: disabled}
- name: fec_extended_encoder_0
  id: fec_extended_encoder
  parameters:
    encoder_list: enc
    puncpat: puncpat
    threadtype: capillary
  states: {state: disabled}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'False'
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: fft_vxx_0_0_0
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'True'
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: fft_vxx_1_0
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'True'
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: header_bits
  id: virtual_sink
  parameters:
    stream_id: Header Bits
  states: {}
- name: import_1
  id: import
  parameters:
    imports: from gnuradio.digital.utils import tagged_streams
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '1472'
    port: '2000'
    send_eof: 'False'
    type: byte
  states: {state: disabled}
- name: qtgui_const_sink_x_0_0_0
  id: qtgui_const_sink_x
  parameters:
    size: '2048'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_1_0
  id: qtgui_const_sink_x
  parameters:
    size: '2048'
    type: complex
    update_time: '0.05'
  states: {}
- name: qtgui_const_sink_x_1_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_eye_sink_x_0_0
  id: qtgui_eye_sink_x
  parameters:
    autoscale: 'True'
    samp_per_symbol: sps
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '64'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_2_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: tddModules_msgStrobeTddRx_0
  id: tddModules_msgStrobeTddRx
  parameters:
    guard_time: guard_time_ms
    switch_interval: half_period_ms
  states: {}
- name: tddModules_msgStrobeTddTx_1
  id: tddModules_msgStrobeTddTx
  parameters:
    guard_time: '10'
    switch_interval: '500'
  states: {state: disabled}
- name: tddModules_nullSinkLat_0
  id: tddModules_nullSinkLat
  parameters:
    granularity: '32768'
    type: complex
  states: {state: disabled}
- name: tddModules_randomSrcTdd_0
  id: tddModules_randomSrcTdd
  parameters:
    mode: '0'
    samples_per_sec: '5000000'
    tx_time_interval: (half_period_ms-guard_time_ms)/1000
  states: {}
- name: tddModules_randomToggleSource_p_0
  id: tddModules_randomToggleSource_p
  parameters:
    samples_per_sec: 100e6
    tx_time_interval: '0.4'
  states: {state: disabled}
- name: tddModules_tddTagStreamMux_0
  id: tddModules_tddTagStreamMux
  parameters:
    lengthtagname: '"frame_len"'
    ninputs: '2'
    tag_preserve_head_pos: '0'
    type: complex
    vlen: '1'
  states: {}
- name: tddModules_tdd_ofdm_cyclic_prefixer_0
  id: tddModules_tdd_ofdm_cyclic_prefixer
  parameters:
    cp_len: '[fft_len//4]'
    input_size: fft_len
    rolloff: rolloff
    tagname: '"frame_len"'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: band_width
    center_freq0: 20e8
    dev_addr: '"addr=192.168.30.3"'
    gain0: '25'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    bw0: band_width
    center_freq0: 20e8
    dev_addr: '"addr=192.168.30.3"'
    gain0: '20'
    samp_rate: samp_rate
    sync: pc_clock_next_pps
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: file_pause
  states: {state: disabled}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: Payload Bits
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: Pre-OFDM
  states: {}
- name: virtual_sink_0_0_1
  id: virtual_sink
  parameters:
    stream_id: Header Stream
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: Time Domain
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: sw_st
  states: {}
- name: virtual_sink_1_0_0
  id: virtual_sink
  parameters:
    stream_id: Payload IQ
  states: {}
- name: virtual_sink_1_1
  id: virtual_sink
  parameters:
    stream_id: Payload Stream
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: file_pause
  states: {state: disabled}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: Pre-OFDM
  states: {}
- name: virtual_source_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: Time Domain
  states: {}
- name: virtual_source_0_0_0_1
  id: virtual_source
  parameters:
    stream_id: Payload IQ
  states: {}
- name: virtual_source_0_0_1
  id: virtual_source
  parameters:
    stream_id: Payload Bits
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: Header Bits
  states: {}
- name: virtual_source_0_1_0
  id: virtual_source
  parameters:
    stream_id: Header Stream
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: sw_st
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: Payload Stream
  states: {}

connections:
- [analog_frequency_modulator_fc_0_0, '0', blocks_multiply_xx_0_0, '0']
- [analog_frequency_modulator_fc_0_0, '0', qtgui_const_sink_x_1_0, '0']
- [analog_frequency_modulator_fc_0_0, '0', qtgui_time_sink_x_1_0_0, '0']
- [analog_random_source_x_0, '0', blocks_stream_to_tagged_stream_0_0, '0']
- [blocks_char_to_float_0, '0', fec_extended_decoder_0, '0']
- [blocks_copy_0, '0', blocks_delay_0_0, '0']
- [blocks_copy_0, '0', digital_ofdm_sync_sc_cfb_0_0, '0']
- [blocks_copy_0, '0', qtgui_time_sink_x_2_0, '0']
- [blocks_delay_0_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_file_source_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_message_strobe_0, strobe, epy_block_1, usrp_toggle]
- [blocks_message_strobe_0, strobe, virtual_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_tag_gate_0, '0']
- [blocks_multiply_xx_0_0, '0', digital_header_payload_demux_0_0, '0']
- [blocks_multiply_xx_0_0, '0', qtgui_eye_sink_x_0_0, '0']
- [blocks_pack_k_bits_bb_0, '0', network_udp_sink_0, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [blocks_repack_bits_bb_0_0, '0', blocks_tag_debug_2_0_2, '0']
- [blocks_repack_bits_bb_0_0, '0', blocks_tag_debug_2_3, '0']
- [blocks_repack_bits_bb_0_0, '0', virtual_sink_0_0, '0']
- [blocks_repack_bits_bb_0_0_0, '0', blocks_char_to_float_0, '0']
- [blocks_repack_bits_bb_0_0_0, '0', blocks_file_sink_0_1_0_0, '0']
- [blocks_repack_bits_bb_0_0_0, '0', blocks_file_sink_0_3_2_1_1_0_0_0_0_0, '0']
- [blocks_repack_bits_bb_0_0_0, '0', blocks_probe_rate_0, '0']
- [blocks_repack_bits_bb_0_0_0, '0', epy_block_3, '0']
- [blocks_repack_bits_bb_0_0_0, '0', tddModules_msgStrobeTddRx_0, '0']
- [blocks_stream_to_tagged_stream_0_0, '0', blocks_repack_bits_bb_0_0, '0']
- [blocks_stream_to_tagged_stream_0_0, '0', blocks_tag_debug_2_0_2_0, '0']
- [blocks_stream_to_tagged_stream_0_0, '0', blocks_tag_debug_2_3_0, '0']
- [blocks_stream_to_tagged_stream_0_0, '0', digital_packet_headergenerator_bb_0, '0']
- [blocks_tag_gate_0, '0', blocks_copy_0, '0']
- [blocks_tag_gate_0, '0', blocks_null_sink_2, '0']
- [blocks_tag_gate_0, '0', blocks_tag_debug_0, '0']
- [blocks_tag_gate_0, '0', epy_block_1, '0']
- [blocks_tag_gate_0, '0', tddModules_nullSinkLat_0, '0']
- [blocks_tag_gate_0, '0', uhd_usrp_sink_0, '0']
- [blocks_tagged_stream_mux_0, '0', blocks_tag_debug_2, '0']
- [blocks_tagged_stream_mux_0, '0', blocks_tag_debug_2_0, '0']
- [blocks_tagged_stream_mux_0, '0', virtual_sink_0_0_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', fec_extended_encoder_0, '0']
- [blocks_vector_to_stream_1, '0', blocks_null_sink_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_tagged_stream_mux_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', tddModules_tddTagStreamMux_0, '0']
- [digital_chunks_to_symbols_xx_0_0, '0', blocks_tagged_stream_mux_0, '1']
- [digital_chunks_to_symbols_xx_0_0, '0', tddModules_tddTagStreamMux_0, '1']
- [digital_constellation_decoder_cb_0_0, '0', digital_packet_headerparser_b_0_0, '0']
- [digital_constellation_decoder_cb_1_0, '0', blocks_repack_bits_bb_0_0_0, '0']
- [digital_header_payload_demux_0_0, '0', virtual_sink_0_0_1, '0']
- [digital_header_payload_demux_0_0, '1', blocks_vector_to_stream_1, '0']
- [digital_header_payload_demux_0_0, '1', virtual_sink_1_1, '0']
- [digital_map_bb_0, '0', blocks_stream_to_tagged_stream_0_0, '0']
- [digital_ofdm_carrier_allocator_cvc_0, '0', blocks_tag_debug_2_0_0, '0']
- [digital_ofdm_carrier_allocator_cvc_0, '0', blocks_tag_debug_2_1, '0']
- [digital_ofdm_carrier_allocator_cvc_0, '0', fft_vxx_0_0, '0']
- [digital_ofdm_chanest_vcvc_0_0, '0', digital_ofdm_frame_equalizer_vcvc_0_0, '0']
- [digital_ofdm_cyclic_prefixer_0, '0', virtual_sink_0_1, '0']
- [digital_ofdm_frame_equalizer_vcvc_0_0, '0', digital_ofdm_serializer_vcc_header_0, '0']
- [digital_ofdm_frame_equalizer_vcvc_1_0, '0', digital_ofdm_serializer_vcc_payload_0, '0']
- [digital_ofdm_serializer_vcc_header_0, '0', blocks_file_sink_0_3_2_0_0_0_0, '0']
- [digital_ofdm_serializer_vcc_header_0, '0', digital_constellation_decoder_cb_0_0, '0']
- [digital_ofdm_serializer_vcc_header_0, '0', qtgui_const_sink_x_0_0_0, '0']
- [digital_ofdm_serializer_vcc_payload_0, '0', blocks_file_sink_0_3_2_1_1_0_0_0_0, '0']
- [digital_ofdm_serializer_vcc_payload_0, '0', qtgui_const_sink_x_0_1_0, '0']
- [digital_ofdm_serializer_vcc_payload_0, '0', virtual_sink_1_0_0, '0']
- [digital_ofdm_sync_sc_cfb_0_0, '0', analog_frequency_modulator_fc_0_0, '0']
- [digital_ofdm_sync_sc_cfb_0_0, '1', digital_header_payload_demux_0_0, '1']
- [digital_ofdm_sync_sc_cfb_0_0, '2', qtgui_time_sink_x_0, '0']
- [digital_packet_headergenerator_bb_0, '0', blocks_tag_debug_2_0_1, '0']
- [digital_packet_headergenerator_bb_0, '0', blocks_tag_debug_2_2, '0']
- [digital_packet_headergenerator_bb_0, '0', header_bits, '0']
- [digital_packet_headerparser_b_0_0, header_data, digital_header_payload_demux_0_0, header_data]
- [epy_block_1, '0', uhd_usrp_sink_0, '0']
- [epy_block_2, '0', blocks_stream_to_tagged_stream_0_0, '0']
- [epy_block_3, '0', blocks_null_sink_1, '0']
- [epy_block_3, sw_st_trigger, virtual_sink_1, '0']
- [epy_block_3, usrp_trigger, uhd_usrp_source_0_0, command]
- [fec_extended_decoder_0, '0', blocks_pack_k_bits_bb_0, '0']
- [fec_extended_encoder_0, '0', digital_map_bb_0, '0']
- [fft_vxx_0_0, '0', blocks_tag_debug_2_0_0_0, '0']
- [fft_vxx_0_0, '0', blocks_tag_debug_2_1_0, '0']
- [fft_vxx_0_0, '0', digital_ofdm_cyclic_prefixer_0, '0']
- [fft_vxx_0_0, '0', tddModules_tdd_ofdm_cyclic_prefixer_0, '0']
- [fft_vxx_0_0_0, '0', digital_ofdm_chanest_vcvc_0_0, '0']
- [fft_vxx_1_0, '0', digital_ofdm_frame_equalizer_vcvc_1_0, '0']
- [tddModules_msgStrobeTddRx_0, sw_st_trigger, virtual_sink_1, '0']
- [tddModules_msgStrobeTddTx_1, sw_st_trigger, blocks_message_debug_1, print]
- [tddModules_msgStrobeTddTx_1, sw_st_trigger, virtual_sink_1, '0']
- [tddModules_randomSrcTdd_0, '0', blocks_stream_to_tagged_stream_0_0, '0']
- [tddModules_randomToggleSource_p_0, '0', blocks_stream_to_tagged_stream_0_0, '0']
- [tddModules_tddTagStreamMux_0, '0', virtual_sink_0_0_0, '0']
- [tddModules_tdd_ofdm_cyclic_prefixer_0, '0', blocks_tag_debug_2_0_0_1, '0']
- [tddModules_tdd_ofdm_cyclic_prefixer_0, '0', blocks_tag_debug_2_1_1, '0']
- [tddModules_tdd_ofdm_cyclic_prefixer_0, '0', virtual_sink_0_1, '0']
- [uhd_usrp_source_0_0, '0', blocks_delay_0_0, '0']
- [uhd_usrp_source_0_0, '0', digital_ofdm_sync_sc_cfb_0_0, '0']
- [uhd_usrp_source_0_0, '0', qtgui_time_sink_x_2_0, '0']
- [virtual_source_0, '0', epy_block_2, file_pause]
- [virtual_source_0_0_0, '0', digital_ofdm_carrier_allocator_cvc_0, '0']
- [virtual_source_0_0_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [virtual_source_0_0_0_1, '0', digital_constellation_decoder_cb_1_0, '0']
- [virtual_source_0_0_1, '0', digital_chunks_to_symbols_xx_0_0, '0']
- [virtual_source_0_1, '0', digital_chunks_to_symbols_xx_0, '0']
- [virtual_source_0_1_0, '0', fft_vxx_0_0_0, '0']
- [virtual_source_1, '0', epy_block_2, file_pause]
- [virtual_source_1, '0', tddModules_randomSrcTdd_0, src_trig]
- [virtual_source_1, '0', tddModules_randomToggleSource_p_0, src_pause]
- [virtual_source_1_0, '0', fft_vxx_1_0, '0']

metadata:
  file_format: 1
  grc_version: g7284103
